# Keil uVision project RGB_V01.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RGB_V01
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./HAL/LED/: LED_program.c LED_config.h LED_interface.h
    ./HAL/BTN/: button_program.c button_config.h button_interface.h
    ./MCAL/GPIO/: GPIO_program.c GPIO_interface.h GPIO_private.h
    ./APP/: APP.c APP.h
    ./SERVICE/: common_macros.h standard_types.h
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
